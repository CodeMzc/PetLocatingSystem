# Keil uVision project Project.uvprojx, settings and files
target Project (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\USER;..\LIB\inc;..\CMSIS;..\BSP\LED;..\BSP\SysTick;..\BSP\Key;..\BSP\USART;..\BSP\TIMER;..\BSP\USART3;..\BSP\delay;..\BSP\TIMER7;..\BSP\sys;..\BSP\GPS;..\MALLOC;..\TEXT;..\PICTURE;..\FATFS\src;..\USMART;..\BSP\LCD;..\BSP\SDIO;..\BSP\SPI;..\BSP\W25QXX;..\FATFS\exfuns;..\FATFS\src\option;..\CMSIS\startup\arm;..\BSP\SDIO;..\BSP\OV7670;..\BSP\EXTI
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c
  group BSP
    ../BSP/USART/: usart.c
    ../BSP/Key/: key.c
    ../BSP/LED/: Led.c
    ../BSP/TIMER/: timer.c
    ../BSP/USART3/: usart3.c
    ../BSP/GPS/: gps.c
    ../BSP/delay/: delay.c
    ../BSP/sys/: sys.c
    ../BSP/LCD/: lcd.c
    ../BSP/SDIO/: sdio_sdcard.c
    ../BSP/SPI/: spi.c
    ../BSP/W25QXX/: w25qxx.c
    ../BSP/OV7670/: ov7670.c sccb.c
    ../BSP/EXTI/: exti.c
  group LIB
    ../LIB/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_sdio.c stm32f10x_rtc.c stm32f10x_flash.c stm32f10x_dma.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group STARTUP
    ../CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c mycc936.c fattester.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group TEXT
    ../TEXT/: text.c fontupd.c
  group PICTURE
    ../PICTURE/: bmp.c gif.c piclib.c tjpgd.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
