# Keil uVision project Project.uvprojx, settings and files
target Project (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1
  c include: ..\USER;..\LIB\inc;..\CMSIS;..\BSP\LED;..\BSP\SysTick;..\BSP\Key;..\BSP\USART;..\BSP\TIMER;..\BSP\USART3;..\BSP\delay;..\BSP\TIMER7;..\BSP\sys;..\BSP\GPS;..\MALLOC;..\USMART;..\BSP\LCD;..\CMSIS\startup\arm;..\BSP\EXTI;..\BSP\MPU6050;..\BSP\MPU6050\eMPL
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c
  group BSP
    ../BSP/USART/: usart.c
    ../BSP/Key/: key.c
    ../BSP/LED/: Led.c
    ../BSP/TIMER/: timer.c
    ../BSP/USART3/: usart3.c
    ../BSP/GPS/: gps.c
    ../BSP/delay/: delay.c
    ../BSP/sys/: sys.c
    ../BSP/LCD/: lcd.c
    ../BSP/MPU6050/: mpu6050.c mpuiic.c
    ../BSP/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group LIB
    ../LIB/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_sdio.c stm32f10x_rtc.c stm32f10x_flash.c stm32f10x_dma.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group STARTUP
    ../CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group MALLOC
    ../MALLOC/: malloc.c
  group ::Device
    RTE/Device/STM32F103ZE/: RTE_Device.h startup_stm32f10x_hd.s system_stm32f10x.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
